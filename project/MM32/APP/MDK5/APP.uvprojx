# Keil uVision project APP.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C8T MindMotion
  pack: MindMotion.MM32F031_DFP.1.3.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: APP
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32F031x8\HAL_lib\inc;..\..\Device\MM32F031x8\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\HARDWARE\TIM;..\HARDWARE\UART_NVIC;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../Device/MM32F031x8/Source/: system_MM32F031x8.c
    ../../Device/MM32F031x8/Source/KEIL_StartAsm/: startup_MM32F031x8.s
  group HARDWARE
    ../HARDWARE/TIM/: tim3.c
    ../HARDWARE/UART_NVIC/: uart_nvic.c
    ../HARDWARE/LED/: led.c
  group HALlib
    ../../Device/MM32F031x8/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group USER
    ../USER/: main.c
