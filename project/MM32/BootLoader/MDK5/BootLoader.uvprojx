# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BootLoader
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32F031x8\HAL_lib\inc;..\..\Device\MM32F031x8\Include;..\USER\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\HARDWARE\UART_NVIC;..\HARDWARE\TIM;..\HARDWARE\PROTECT
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group STARTUP
    ../../Device/MM32F031x8/Source/: system_MM32F031x8.c
    ../../Device/MM32F031x8/Source/KEIL_StartAsm/: startup_MM32F031x8.s
  group HALlib
    ../../Device/MM32F031x8/HAL_lib/src/: HAL_bkp.c HAL_flash.c HAL_gpio.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_syscfg.c HAL_tim.c HAL_uart.c
  group HARDWARE
    ../HARDWARE/UART_NVIC/: uart_nvic.c
    ../HARDWARE/TIM/: tim3.c
    ../HARDWARE/PROTECT/: protect.c
  group USER
    ../USER/src/: Boot.c dfu_mal.c main.c
  group SYSTEM
    ../SYSTEM/uart/: uart.c
    ../SYSTEM/sys/: sys.c
