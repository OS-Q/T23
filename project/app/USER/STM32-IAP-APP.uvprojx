# Keil uVision project STM32-IAP-APP.uvprojx, settings and files
target STM32-IAP-APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  AfterMake: .\..\..\Binary\hex2bin.exe .\..\OUTPUT\Demo.hex
  AfterMake: .\..\..\Binary\hex2dfu.exe -t .\..\OUTPUT\Demo.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\BSP\LED;..\SYS\delay;..\SYS\sys;..\SYS\usart;..\USER;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\CORE;..\BSP\KEY;..\BSP\LCD;..\BSP\RTC;..\BSP\RTC;..\BSP\WKUP;..\BSP\ADC;..\BSP\DAC;..\BSP\DMA;..\BSP\IIC;..\BSP\24CXX;..\BSP\SPI;..\BSP\FLASH;..\BSP\TOUCH;..\BSP\REMOTE;..\BSP\ADXL345;..\BSP\DS18B20;..\BSP\STMFLASH;..\USMART;..\SYS\iap
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/LED/: led.c
    ../BSP/LCD/: lcd.c
    ../BSP/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYS/delay/: delay.c
    ../SYS/sys/: sys.c
    ../SYS/usart/: usart.c
    ../SYS/iap/: iap.c
  group CORE
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group FWLib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_bkp.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
software components: CMSIS:CORE 5.1.2
